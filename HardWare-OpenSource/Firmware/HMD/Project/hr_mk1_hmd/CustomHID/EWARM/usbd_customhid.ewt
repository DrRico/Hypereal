<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM324xG-EVAL_USBD-FS</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\src\app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\calibrate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\fpga_coprocesser.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\hmc5883l.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\inc\hr_mk1_config.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\imu_data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\max21100.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\SI4432.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\stm32fxxx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usb_bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usbd_desc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usbd_trans.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\usbd_usr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\wireless_phase_control.c</name>
    </file>
  </group>
  <group>
    <name>STM32F4xx</name>
    <group>
      <name>STM32F4xx_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dsi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash_ramfunc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fmpi2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_lptim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_qspi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spdifrx.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\startup_stm32f40xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\system_stm32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>USB Device</name>
    <group>
      <name>Class</name>
      <group>
        <name>CUSTOMHID</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32_USB_Device_Library\Class\customhid\src\usbd_customhid_core.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Library</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_ioreq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32_USB_Device_Library\Core\src\usbd_req.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>USB Drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_dcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32_USB_OTG_Driver\src\usb_dcd_int.c</name>
    </file>
  </group>
</project>


